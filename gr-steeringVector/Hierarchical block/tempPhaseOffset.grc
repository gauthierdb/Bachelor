<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tempPhaseOffset</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftSize</value></param>
<param><key>value</key><value>fft_size/N</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0_0</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_1</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_1</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_1_0</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_2</value></param>
<param><key>n</key><value>N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>8</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>2**13</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iterationCount</value></param>
<param><key>label</key><value>iterationCount</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>num_streams</key><value>8</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>steeringVector_multiplyComplex</key>
<param><key>id</key><value>steeringVector_multiplyComplex_0</value></param>
</block>
<block>
<key>steeringVector_multiplyComplex</key>
<param><key>id</key><value>steeringVector_multiplyComplex_0_0</value></param>
</block>
<block>
<key>steeringVector_multiplyComplex</key>
<param><key>id</key><value>steeringVector_multiplyComplex_0_0_0</value></param>
</block>
<block>
<key>steeringVector_multiplyComplex</key>
<param><key>id</key><value>steeringVector_multiplyComplex_0_0_0_0</value></param>
</block>
<block>
<key>steeringVector_multiplyComplex</key>
<param><key>id</key><value>steeringVector_multiplyComplex_0_0_1</value></param>
</block>
<block>
<key>steeringVector_multiplyComplex</key>
<param><key>id</key><value>steeringVector_multiplyComplex_0_1</value></param>
</block>
<block>
<key>steeringVector_multiplyComplex</key>
<param><key>id</key><value>steeringVector_multiplyComplex_0_1_0</value></param>
</block>
<block>
<key>steeringVector_multiplyComplex</key>
<param><key>id</key><value>steeringVector_multiplyComplex_0_2</value></param>
</block>
<block>
<key>steeringVector_phaseOffset</key>
<param><key>id</key><value>steeringVector_phaseOffset_0</value></param>
<param><key>isActive</key><value>True</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<block>
<key>steeringVector_phaseOffset</key>
<param><key>id</key><value>steeringVector_phaseOffset_0_0</value></param>
<param><key>isActive</key><value>True</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<block>
<key>steeringVector_phaseOffset</key>
<param><key>id</key><value>steeringVector_phaseOffset_0_0_0</value></param>
<param><key>isActive</key><value>True</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<block>
<key>steeringVector_phaseOffset</key>
<param><key>id</key><value>steeringVector_phaseOffset_0_0_1</value></param>
<param><key>isActive</key><value>True</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<block>
<key>steeringVector_phaseOffset</key>
<param><key>id</key><value>steeringVector_phaseOffset_0_0_2</value></param>
<param><key>isActive</key><value>True</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<block>
<key>steeringVector_phaseOffset</key>
<param><key>id</key><value>steeringVector_phaseOffset_0_1</value></param>
<param><key>isActive</key><value>True</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<block>
<key>steeringVector_phaseOffset</key>
<param><key>id</key><value>steeringVector_phaseOffset_0_2</value></param>
<param><key>isActive</key><value>True</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<block>
<key>steeringVector_phaseOffset</key>
<param><key>id</key><value>steeringVector_phaseOffset_0_3</value></param>
<param><key>isActive</key><value>True</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_1_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_2</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_2</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_2</source_block_id><sink_block_id>steeringVector_phaseOffset_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_3</source_block_id><sink_block_id>steeringVector_phaseOffset_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_2</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_2</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_1</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_0_1</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_1_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_1_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0</sink_block_id><source_key>out</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0</sink_block_id><source_key>out</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_0</sink_block_id><source_key>out</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_1</sink_block_id><source_key>out</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_0_2</sink_block_id><source_key>out</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_1</sink_block_id><source_key>out</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_2</sink_block_id><source_key>out</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>steeringVector_phaseOffset_0_3</sink_block_id><source_key>out</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>steeringVector_multiplyComplex_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>steeringVector_multiplyComplex_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>steeringVector_multiplyComplex_0_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>steeringVector_multiplyComplex_0_0_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>steeringVector_multiplyComplex_0_0_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>steeringVector_multiplyComplex_0_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>steeringVector_multiplyComplex_0_1_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>steeringVector_multiplyComplex_0_2</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0</sink_block_id><source_key>multiplyConst</source_key><sink_key>multiplyConst</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_0</sink_block_id><source_key>multiplyConst</source_key><sink_key>multiplyConst</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_0_0</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_0_0</sink_block_id><source_key>multiplyConst</source_key><sink_key>multiplyConst</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_0_1</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_0_1</sink_block_id><source_key>multiplyConst</source_key><sink_key>multiplyConst</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_0_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_0_2</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_0_0_0</sink_block_id><source_key>multiplyConst</source_key><sink_key>multiplyConst</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_0_2</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_1</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_1</sink_block_id><source_key>multiplyConst</source_key><sink_key>multiplyConst</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_2</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_2</sink_block_id><source_key>multiplyConst</source_key><sink_key>multiplyConst</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_2</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_3</source_block_id><sink_block_id>steeringVector_multiplyComplex_0_1_0</sink_block_id><source_key>multiplyConst</source_key><sink_key>multiplyConst</sink_key></connection>
<connection><source_block_id>steeringVector_phaseOffset_0_3</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
</flow_graph>
