<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>calib</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>calib</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>doa_delay</key>
<param><key>id</key><value>DelayBlock1</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>doa_delay</key>
<param><key>id</key><value>DelayBlock1_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_2</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_2_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>file</key><value>path + "/rtl2"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_2</value></param>
<param><key>file</key><value>path  + "/rtl1"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_1</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_1_0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_11</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_12</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftSize</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devices</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl=00000001, rtl=00000002, rtl=00000003, rtl=00000004"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftSize</value></param>
<param><key>value</key><value>2**13</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>862.8e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iterationCount</value></param>
<param><key>label</key><value>iterationCount</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/home/gauthier/Downloads/5min"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>no steer</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>steer 1</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>steer 2</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>trigger</value></param>
<param><key>name</key><value>Phase difference steerVector</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>3</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ylabel</key><value>"Time"</value></param>
<param><key>yunit</key><value>"Phase (-Pi to Pi)"</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>steeringVector_messageAtThreshold</key>
<param><key>id</key><value>steeringVector_messageAtThreshold_0</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>initial_state</key><value>0</value></param>
<param><key>isActive</key><value>calib</value></param>
<param><key>threshHigh</key><value>0.8</value></param>
<param><key>threshLow</key><value>0.6</value></param>
</block>
<block>
<key>steeringVector_sample_offset_multi</key>
<param><key>id</key><value>steeringVector_sample_offset_multi_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vector_count</key><value>iterationCount</value></param>
<param><key>vector_length</key><value>fftSize</value></param>
</block>
<block>
<key>steeringVector_steeringVector</key>
<param><key>id</key><value>steeringVector_steeringVector_0</value></param>
<param><key>arrayLength</key><value>1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>arraySpacing</key><value>0.45</value></param>
<param><key>refAngle</key><value>70</value></param>
<param><key>vectorLength</key><value>1</value></param>
</block>
<block>
<key>steeringVector_steeringVector</key>
<param><key>id</key><value>steeringVector_steeringVector_0_0</value></param>
<param><key>arrayLength</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>arraySpacing</key><value>0.45</value></param>
<param><key>refAngle</key><value>70</value></param>
<param><key>vectorLength</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>rtl2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>rtl2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0_0</value></param>
<param><key>stream_id</key><value>rtl1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0_0_0</value></param>
<param><key>stream_id</key><value>rtl2</value></param>
</block>
<connection><source_block_id>DelayBlock1</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DelayBlock1</source_block_id><sink_block_id>steeringVector_steeringVector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DelayBlock1</source_block_id><sink_block_id>steeringVector_steeringVector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DelayBlock1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DelayBlock1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DelayBlock1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DelayBlock1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DelayBlock1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_2</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_2_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_2</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_1</source_block_id><sink_block_id>blocks_complex_to_arg_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_1_0</source_block_id><sink_block_id>blocks_complex_to_arg_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_11</source_block_id><sink_block_id>steeringVector_sample_offset_multi_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_12</source_block_id><sink_block_id>steeringVector_sample_offset_multi_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_1</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>steeringVector_messageAtThreshold_0</source_block_id><sink_block_id>steeringVector_sample_offset_multi_0</sink_block_id><source_key>recalcDelay</source_key><sink_key>recalc</sink_key></connection>
<connection><source_block_id>steeringVector_sample_offset_multi_0</source_block_id><sink_block_id>DelayBlock1_0</sink_block_id><source_key>recalcOut0</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>steeringVector_sample_offset_multi_0</source_block_id><sink_block_id>DelayBlock1</sink_block_id><source_key>recalcOut1</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>steeringVector_steeringVector_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>steeringVector_steeringVector_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>steeringVector_messageAtThreshold_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_12</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>DelayBlock1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0_0</source_block_id><sink_block_id>DelayBlock1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_11</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
